Commit message: did the trajectories assignment

File: wavyArm/wavyRobot.urdf (robot description, URDF)
Before this commit: robot one_DOF_robot, 4 links, 3 joints
Links:
- link link3: mass .1 -> 1; geometry collision cylinder length=1 radius=0.08; visual cylinder length=1 radius=0.08
